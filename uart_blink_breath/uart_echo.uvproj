# Keil uVision project uart_echo.uvproj, settings and files
target uart_echo (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: uart_echo
  AfterMake: fromelf --bin --output .\rvmdk\uart_echo.bin .\rvmdk\uart_echo.axf
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA0
  c misc: --c99
  c include: ..\..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: uart_echo.sct
  link misc: --entry Reset_Handler
  group Source
    ./: startup_rvmdk.S uart_echo.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
